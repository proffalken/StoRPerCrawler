Commit message: Working!!!

File: storper_sim/urdf/storper.urdf (robot description, URDF)
Before this commit: robot storper, 4 links, 3 joints
Links:
- link left_wheel_link: mass None -> 0.05
- link right_wheel_link: mass None -> 0.05
